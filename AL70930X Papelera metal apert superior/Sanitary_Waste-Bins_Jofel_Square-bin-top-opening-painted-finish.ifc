Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Waste-Bins_Jofel_Square-bin-top-opening-painted-finish.ifc
Time: 2019-01-15T12:04:19
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Square bin top opening painted finish
ePset_BIMobjectScript - Colour: AL709300 - Dark grey; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Square bin top opening painted finish; SKU (BO_prodsku): Square_bin_top_opening_painted_finish; ManufacturName (BO_Manufac): Jofel; BrandUrl (BO_brandurl): http://jofel.com; ProductFamily (BO_prodfam): Bin; ProductGroup (BO_prodgroup): Square bins; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; EditionNumber (BO_edinum): 1; Width (BO_width): 236; Height (BO_height): 700; Depth (BO_depth): 236; Weight (BO_weight): 4.955; QR (BO_boqrurl): http://bimobject.com/jofel/product/Square_bin_top_opening_painted_finish; ProductDataUrl (BO_prodaturl): bimobject.com/jofel/product/Square_bin_top_opening_painted_finish; ProductUrl (BO_producturl): http://jofel.com/en/productos/papeleras-y-ceniceros/papelera-rectangular-pintada-boca-superior-inox.html; TechnicalDescription (BO_techcert): http://jofel.com/media/fichas/en/AL709300.pdf; MaterialMain (BO_mainmat): Metal; MaterialSecondary (BO_secmat): Electrogalvanized; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Waste Bins; BimObjectCategoryCode (BO_bocat_code): sanitary-waste; IfcClassification (BO_ifcclas): Furnishing Element; Uniclass14Code (BO_uniclass_1_4_code): L8113; Uniclass14Description (BO_uniclass_1_4_desc): Bins; Uniclass20Code (BO_uniclass_2_0_code): PR-35-10-97; Uniclass20Description (BO_uniclass_2_0_desc): Waste Bins; Uniclass2015Code (BO_uniclass2015_code): Pr_40_50_07_96; Uniclass2015Description (BO_uniclass2015_desc): Waste bins; NBSReference (BO_nbs_ref): 35-10-97; NBSReferenceDescription (BO_nbs_desc): Waste Bins; OmniClassCode (BO_omniclass_code): 23-21 17 11; OmniClassDescription (BO_omniclass_name): Interior Waste Bins; MasterFormat2014Code (BO_masterformat2014_code): 11 82 13; MasterFormat2014Description (BO_masterformat2014_name): Solid Waste Bins; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW
